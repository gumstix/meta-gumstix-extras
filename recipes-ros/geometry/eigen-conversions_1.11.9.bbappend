FILESEXTRAPATHS_append := "${THISDIR}:"

SRC_URI += "file://0001-find-Eigen-with-cmake_modules-Find-script-partly-rev.patch;patchdir=.."

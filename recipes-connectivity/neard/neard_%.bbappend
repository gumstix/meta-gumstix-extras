# Disable NFC service by default as Gumstix does not have NFC modules

SYSTEMD_AUTO_ENABLE_neard = "disable"

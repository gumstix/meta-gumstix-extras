DESCRIPTION = "Gumstix Network Manager Applet bbappend to fix glib schema"
SECTION = "base"
PR = "r1"

inherit gsettings 

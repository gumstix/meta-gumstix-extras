# Gumstix Network Manager Applet bbappend to fix glib schema

inherit gsettings

FILESEXTRAPATHS := "${THISDIR}/${PN}"
SRC_URI += "file://0001-Removed-to-work-with-non-git-environment.patch  \
           "


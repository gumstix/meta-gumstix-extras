DESCRIPTION = "Gumstix Bash Profile"
SECTION = "base"
LICENSE = "MIT"
PR = "r0"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

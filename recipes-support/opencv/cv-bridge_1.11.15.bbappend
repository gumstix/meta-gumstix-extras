EXTRA_OECMAKE = ""

# This bbappend file is for fixing exsiting error only
# If it does not apply to the newer version, it can be removed

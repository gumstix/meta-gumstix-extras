FILESEXTRAPATHS_prepend := "${TOPDIR}/../poky/meta/recipes-multimedia/gstreamer/files:"
FILESEXTRAPATHS_prepend := "${TOPDIR}/../poky/meta/recipes-multimedia/gstreamer/${PN}:"

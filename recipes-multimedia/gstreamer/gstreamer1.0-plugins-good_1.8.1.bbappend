FILESEXTRAPATHS_prepend := "${TOPDIR}/../poky/meta/recipes-multimedia/gstreamer/files:"

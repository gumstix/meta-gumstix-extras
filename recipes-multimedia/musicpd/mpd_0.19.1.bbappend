SYSTEMD_SERVICE_${PN} += "mpd.socket"

# The original SRCREV is no longer in git. 
# A patch was submitted in upstream, but it has not been backported into daisy yet.  
# Here we are overriding SRCREV with the upstream commit hash.
SRCREV = "ffc3ad4945da69f3caa2b40e4eed715a9a8d9526"

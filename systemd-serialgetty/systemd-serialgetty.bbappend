# Gumstix Serial ttyGS0 Systemd Service for serial console over USB OTG
SERIAL_CONSOLES_append := " 115200;ttyGS0"

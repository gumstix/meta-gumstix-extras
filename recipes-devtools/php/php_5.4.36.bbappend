do_install_append_class-target() {
    rm -rf ${D}${bindir}/phar*
}

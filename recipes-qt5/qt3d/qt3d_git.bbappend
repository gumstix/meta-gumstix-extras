DEPENDS_class-target += "assimp"
# Beagleboard is the supported platform that best matches our GL setup
EGLINFO_DEVICE = "beagleboard"

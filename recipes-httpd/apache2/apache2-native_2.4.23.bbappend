SRC_URI_remove = "http://www.apache.org/dist/httpd/httpd-${PV}.tar.bz2 \"
SRC_URI += "http://archive.apache.org/dist/httpd/httpd-${PV}.tar.bz2 \"
